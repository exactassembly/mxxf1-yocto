FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " \
	file://0002-Add-mxxf1-DT-boards.patch \
"
